## src/modules/levitum/Kconfig
```kconfig
menuconfig MODULES_LEVITUM
	bool "levitum"
	default y
	---help---
		Enable support for levitum stuff
```
